# IAR project cm0plus.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CYT3DL_M0+ Cypress CYT3DL_M0+
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CYT3DLABHS; $DIE$; CY_USE_PSVP=0; CY_MCU_rev_c; CY_216TEQFP_EVKTLD816K
  ICCARM.CCIncludePath2: $BG_ROOT_PATH$\..\$SDL$\$DIE$\hdr\rev_c; $BG_ROOT_PATH$\..\$SDL$\$DIE$\src\system\rev_c; $BG_ROOT_PATH$\..\$SDL$\$DIE$\hdr\rev_c\ip; $BG_ROOT_PATH$\..\$SDL$\common\hdr; $BG_ROOT_PATH$\..\$SDL$\$DIE$\src; $BG_ROOT_PATH$\..\$SDL$\$DIE$\src\mw; $BG_ROOT_PATH$\..\$SDL$\common\src\mw; $BG_ROOT_PATH$\..\$SDL$\common\src\drivers; $BG_ROOT_PATH$\..\$SDL$\$DIE$\src\drivers; $BG_ROOT_PATH$\..\$SDL$\$DIE$\hdr\rev_c\mcureg; $BG_ROOT_PATH$\..\$SDL$\common\hdr\cmsis\include; $BG_ROOT_PATH$\..\$SDL$\$DIE$\src\mw\power; $BG_ROOT_PATH$\..\$SDL$\$DIE$\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: cm0plus.srec
  ILINK.IlinkOutputFile: cm0plus.out
  ILINK.IlinkKeepSymbols: CM7_APP
  ILINK.IlinkConfigDefines: _LINK_flash_=0; _CORE_cm0plus_=0
  ILINK.IlinkIcfFile: ..\linker_directives_$DIE$.icf
  ILINK.IlinkAdditionalLibs: $BG_ROOT_PATH$\..\$SDL$\$DIE$\tools\iar\flash_8.22\libsdl\rev_a\cm0plus\libsdl.a; $BG_ROOT_PATH$\..\$SDL$\$DIE$\tools\iar\flash_8.22\libmw\rev_a\cm0plus\libmw.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: RELEASE; CYT3DLABHS; $DIE$; CY_USE_PSVP=0; CY_MCU_rev_a
  ICCARM.CCIncludePath2: $BG_ROOT_PATH$\$SDL$\$DIE$\hdr\rev_a; $BG_ROOT_PATH$\$SDL$\$DIE$\src\system\rev_a; $BG_ROOT_PATH$\$SDL$\$DIE$\hdr\rev_a\ip; $BG_ROOT_PATH$\$SDL$\common\hdr; $BG_ROOT_PATH$\$SDL$\$DIE$\src; $BG_ROOT_PATH$\$SDL$\$DIE$\src\mw; $BG_ROOT_PATH$\$SDL$\common\src\mw; $BG_ROOT_PATH$\$SDL$\common\src\drivers; $BG_ROOT_PATH$\$SDL$\$DIE$\src\drivers; $BG_ROOT_PATH$\$SDL$\$DIE$\hdr\rev_a\mcureg; $BG_ROOT_PATH$\$SDL$\common\hdr\cmsis\include; $BG_ROOT_PATH$\$SDL$\$DIE$\src\mw\power; $BG_ROOT_PATH$\$SDL$\$DIE$\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: CM7_BIN
  ILINK.IlinkAdditionalLibs: $BG_ROOT_PATH$\$SDL$\$DIE$\tools\iar\flash_8.22\libsdl\cm0plus\libsdl.a; $BG_ROOT_PATH$\$SDL$\$DIE$\tools\iar\flash_8.22\libmw\cm0plus\libmw.a
configuration Production (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: PRODUCTION; CYT3DLABHS; $DIE$; CY_USE_PSVP=0; CY_MCU_rev_a
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkKeepSymbols: CM7_BIN
  ILINK.IlinkAdditionalLibs: as above
  group src
    ../../../src/: main_cm0plus.c
  group startup
    ../../../../../SDL/tviic2d4m/src/interrupts/rev_a/: cy_interrupt_map.c cy_interrupt_map_cm0plus.h
    ../../../../../SDL/common/src/startup/: startup.c startup_customize.h
    ../../../../../SDL/common/src/startup/iar/: startup_cm0plus.s
    ../../../../../SDL/tviic2d4m/src/system/rev_a/: system_cyt3dl.h system_tviic2d4m_cm0plus.c
