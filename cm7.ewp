# IAR project cm7.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CYT3DL_M7 Cypress CYT3DL_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; $DIE$; CYT3DLABHS; CY_CORE_CM7_0; CY_USE_PSVP=0; CY_MCU_rev_c; CY_216TEQFP_EVKTLD816K
  ICCARM.CCIncludePath2: $BG_ROOT_PATH$\..\$SDL$\common\hdr; $BG_ROOT_PATH$\..\$SDL$\common\src\drivers; $BG_ROOT_PATH$\..\$SDL$\common\hdr\cmsis\include; $BG_ROOT_PATH$\..\$SDL$\common\src\mw; $BG_ROOT_PATH$\..\$SDL$\$DIE$\hdr\rev_c; $BG_ROOT_PATH$\..\$SDL$\$DIE$\hdr\rev_c\ip; $BG_ROOT_PATH$\..\$SDL$\$DIE$\src\system\rev_c; $BG_ROOT_PATH$\..\$SDL$\$DIE$\hdr\rev_c\mcureg; $BG_ROOT_PATH$\..\$SDL$\$DIE$\src\drivers; $BG_ROOT_PATH$\..\$SDL$\$DIE$\src; $BG_ROOT_PATH$\..\$SDL$\$DIE$\src\mw
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: cm7.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: _LINK_flash_=0; _CORE_cm7_0_=0
  ILINK.IlinkIcfFile: ..\linker_directives_$DIE$.icf
  ILINK.IlinkAdditionalLibs: $BG_ROOT_PATH$\..\$SDL$\$DIE$\tools\iar\flash_8.22\libsdl\rev_a\cm7\libsdl.a; $BG_ROOT_PATH$\..\$SDL$\$DIE$\tools\iar\flash_8.22\libmw\rev_a\cm7\libmw.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: RELEASE; $DIE$; CYT3DLABHS; CY_CORE_CM7_0; CY_USE_PSVP=0
  ICCARM.CCIncludePath2: $BG_ROOT_PATH$\02_driver\basic_graphics\include; $BG_ROOT_PATH$\05_util\common\include; $BG_ROOT_PATH$\05_util\utgraphic\include; $BG_ROOT_PATH$\$SDL$\common\hdr; $BG_ROOT_PATH$\$SDL$\common\src\drivers; $BG_ROOT_PATH$\$SDL$\common\hdr\cmsis\include; $BG_ROOT_PATH$\$SDL$\common\src\mw; $BG_ROOT_PATH$\$SDL$\$DIE$\hdr\rev_a; $BG_ROOT_PATH$\$SDL$\$DIE$\hdr\rev_a\ip; $BG_ROOT_PATH$\$SDL$\$DIE$\src\system\rev_a; $BG_ROOT_PATH$\$SDL$\$DIE$\hdr\rev_a\mcureg; $BG_ROOT_PATH$\$SDL$\$DIE$\src\drivers; $BG_ROOT_PATH$\$SDL$\$DIE$\src; $BG_ROOT_PATH$\$SDL$\$DIE$\src\mw; $BG_ROOT_PATH$\05_util\hw\include
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: $BG_ROOT_PATH$\$SDL$\$DIE$\tools\iar\flash_8.22\libsdl\cm7\libsdl.a; $BG_ROOT_PATH$\$SDL$\$DIE$\tools\iar\flash_8.22\libmw\cm7\libmw.a; $BG_ROOT_PATH$\01_bin\iar\$DIE$\$CONFIG_NAME$\bin\libbasic_graphics_cm7.a; $BG_ROOT_PATH$\01_bin\iar\$DIE$\$CONFIG_NAME$\bin\libutil_cm7.a
configuration Production (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: PRODUCTION; $DIE$; CYT3DLABHS; CY_CORE_CM7_0; CY_USE_PSVP=0
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: as above
  group (top)
    ../: linker_directives_tviic2d4m.icf
  group src
    ../../../src/: main_cm7.c
  group startup
    ../../../../../SDL/tviic2d4m/src/interrupts/rev_a/: cy_interrupt_map.c cy_interrupt_map_cm7_0.h
    ../../../../../SDL/common/src/startup/: startup.c startup_customize.h
    ../../../../../SDL/common/src/startup/iar/: startup_cm7.s
    ../../../../../SDL/tviic2d4m/src/system/rev_a/: system_cyt3dl.h system_tviic2d4m_cm7.c
